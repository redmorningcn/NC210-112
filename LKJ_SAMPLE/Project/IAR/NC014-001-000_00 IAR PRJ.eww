<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\Library\Project\IAR\NC014-001-000.PRJ_00-Lib.ewp</path>
  </project>
  <batchBuild/>
</workspace>


