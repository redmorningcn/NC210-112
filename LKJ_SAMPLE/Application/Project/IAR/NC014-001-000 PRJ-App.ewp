# IAR project NC014-001-000 PRJ-App.ewp, settings and files
configuration Debug-RC (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; DEBUG; STM32F103RC; STM32_FLASH_SIZE=256
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\Source\APP; ..\..\Source\APP\User; ..\..\Source\APP\AES; ..\..\Source\APP\Config; ..\..\Source\APP\OS; ..\..\Source\APP\User; ..\..\Source\APP\SIM900A\Source; ..\..\Source\APP\SIM900A\Port; ..\..\Source\APP\SIM900A\OS; ..\..\Source\APP\SIM900A\Config; ..\..\Source\APP\Protocol; ..\..\Source\APP\Iap; ..\..\Source\BSP; ..\..\Source\BSP\Driver; ..\..\Source\BSP\IAR; ..\..\Source\BSP\Os; ..\..\Source\BSP\Os\uCOS-III; ..\..\Source\BSP\St; ..\..\Source\BSP\St\FWLib\CMSIS\CM3\CoreSupport; ..\..\Source\BSP\St\FWLib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\Source\BSP\St\FWLib\STM32F10x_StdPeriph_Driver\inc; ..\..\Source\Micrium\uC-CPU; ..\..\Source\Micrium\uC-CPU\ARM-Cortex-M3\IAR; ..\..\Source\Micrium\uC-LIB; ..\..\Source\BSP\Os\OSAL; ..\..\Source\OSAL\OS; ..\..\Source\Micrium\uC-MB; ..\..\Source\Micrium\uC-MB\Cfg\Template; ..\..\Source\Micrium\uC-MB\OS\uCOS-III; ..\..\Source\Micrium\uC-MB\Source; ..\..\Source\Micrium\uC-OS-III; ..\..\Source\Micrium\uC-OS-III\Ports\ARM-Cortex-M3\Generic\IAR; ..\..\Source\Micrium\uC-OS-III\Source; ..\..\Source\FatFs; ..\..\Source\FatFs\option; $TOOLKIT_DIR$\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NC136B-120-000.CX_00_Debug-RC.bin
  ILINK.IlinkOutputFile: OS.out
  ILINK.IlinkIcfFile: ..\..\Source\BSP\IAR\STM32_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release-RC (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; RELEASE; STM32F103RC; STM32_FLASH_SIZE=256
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\Source\APP; ..\..\Source\APP\User; ..\..\Source\APP\AES; ..\..\Source\APP\Config; ..\..\Source\APP\OS; ..\..\Source\APP\User; ..\..\Source\APP\SIM900A\Source; ..\..\Source\APP\SIM900A\Port; ..\..\Source\APP\SIM900A\OS; ..\..\Source\APP\SIM900A\Config; ..\..\Source\APP\Protocol; ..\..\Source\APP\Iap; ..\..\Source\BSP; ..\..\Source\BSP\Driver; ..\..\Source\BSP\IAR; ..\..\Source\BSP\Os; ..\..\Source\BSP\Os\uCOS-III; ..\..\Source\BSP\St; ..\..\Source\BSP\St\FWLib\CMSIS\CM3\CoreSupport; ..\..\Source\BSP\St\FWLib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\Source\BSP\St\FWLib\STM32F10x_StdPeriph_Driver\inc; ..\..\Source\Micrium\uC-CPU; ..\..\Source\Micrium\uC-CPU\ARM-Cortex-M3\IAR; ..\..\Source\Micrium\uC-LIB; ..\..\Source\BSP\Os\OSAL; ..\..\Source\OSAL\OS; ..\..\Source\Micrium\uC-MB; ..\..\Source\Micrium\uC-MB\Cfg\Template; ..\..\Source\Micrium\uC-MB\OS\uCOS-III; ..\..\Source\Micrium\uC-MB\Source; ..\..\Source\Micrium\uC-OS-III; ..\..\Source\Micrium\uC-OS-III\Ports\ARM-Cortex-M3\Generic\IAR; ..\..\Source\Micrium\uC-OS-III\Source; ..\..\Source\FatFs; ..\..\Source\FatFs\option
  OBJCOPY.OOCOutputFile: NC136B-120-000.CX_00_Release-RC.bin
configuration Debug-RC-A (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; DEBUG; IMAGE_A; STM32F103RC; STM32_FLASH_SIZE=256
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: NC136B-120-000.CX_00_Debug-RC_IMAGE_A.bin
  ILINK.IlinkIcfFile: ..\..\Source\BSP\IAR\STM32_Flash_A.icf
configuration Release-RC-A (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; RELEASE; IMAGE_A; STM32F103RC; STM32_FLASH_SIZE=256
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: NC136B-120-000.CX_00_Release-RC_IMAGE_A.bin
  ILINK.IlinkIcfFile: ..\..\Source\BSP\IAR\STM32_Flash_A.icf
  group (top)
    ./: UpdateLog.log
  group APP
    ../../Source/APP/: main.c
  group APP/Config
    ../../Source/APP/Config/: app_cfg.h cpu_cfg.h lib_cfg.h os_cfg.h os_cfg_app.h stm32f10x_conf.h
  group APP/Iap
    ../../Source/APP/Iap/: iap.h
  group APP/Tasks
    ../../Source/APP/Tasks/: app_task_comm.c app_task_osal_disp.c app_task_osal_sen.c
  group APP/User
    ../../Source/APP/User/: app.h app_calc.h app_ctrl.h app_lib.h app_var.c global.h includes.h
  group BSP
    ../../Source/BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c STM32F103RC-IAR-Lib.A
  group BSP/Driver/Board/Inc
    ../../Source/BSP/Driver/: bsp_adc7682.h bsp_control.h bsp_dataconversion.h bsp_eeprom.h bsp_filteralgorithm.h bsp_key.h bsp_max7219.h
  group BSP/Driver/Board/Src
    ../../Source/BSP/Driver/: bsp_adc7682.c bsp_control.c bsp_dataconversion.c bsp_eeprom.c bsp_filteralgorithm.c bsp_key.c bsp_max7219.c
  group BSP/Driver/Mcu/Inc
    ../../Source/BSP/Driver/: bsp_adc.h bsp_flash.h bsp_info.h bsp_pwm.h bsp_rst.h bsp_rtc.h bsp_time.h bsp_usart.h bsp_wdt.h
  group BSP/Driver/Mcu/Src
    ../../Source/BSP/Driver/: bsp_adc.c bsp_flash.c bsp_info.c bsp_pwm.c bsp_rst.c bsp_rtc.c bsp_time.c bsp_usart.c bsp_wdt.c
  group BSP/ST/FWLib/CMSIS
    ../../Source/BSP/ST/FWLib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.h
  group BSP/ST/FWLib/inc
    ../../Source/BSP/ST/FWLib/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group BSP/ST/FWLib/src
    ../../Source/BSP/ST/FWLib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group OSAL/OS
    ../../Source/OSAL/OS/: osal.h osal_cpu.h osal_event.h osal_memory.h osal_timer.h
  group OSAL/Ports
    ../../Source/BSP/OS/OSAL/: bsp_hal.h bsp_timer.h
  group uC/CPU
    ../../Source/Micrium/uC-CPU/: cpu_core.h cpu_def.h
  group uC/CPU/IAR
    ../../Source/Micrium/uC-CPU/ARM-Cortex-M3/IAR/: cpu.h
  group uC/LIB
    ../../Source/Micrium/uC-LIB/: lib_ascii.h lib_def.h lib_math.h lib_mem.h lib_str.h
  group uC/LIB/Ports
    ../../Source/Micrium/uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group uC/MB/Cfg
    ../../Source/Micrium/uC-MB/Cfg/Template/: mb_app_hooks.c mb_app_hooks.h mb_cfg.h MB_DATA.C
  group uC/MB/Ports
    ../../Source/Micrium/uC-MB/Ports/STM32/STM32F103/IAR/: MB_BSP.C
  group uC/OS-III/Port
    ../../Source/Micrium/uC-OS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h
  group uC/OS-III/Source
    ../../Source/Micrium/uC-OS-III/Source/: os.h os_type.h
