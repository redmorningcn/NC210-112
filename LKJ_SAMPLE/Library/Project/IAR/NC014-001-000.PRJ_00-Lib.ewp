# IAR project NC014-001-000.PRJ_00-Lib.ewp, settings and files
configuration Debug-RC (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; _STM32F10X_CL; DEBUG; STM32F103RC; STM32_FLASH_SIZE=256; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\Source\APP; ..\..\Source\APP\User; ..\..\Source\APP\AES; ..\..\Source\APP\Config; ..\..\Source\APP\OS; ..\..\Source\APP\User; ..\..\Source\APP\SIM900A\Source; ..\..\Source\APP\SIM900A\Port; ..\..\Source\APP\SIM900A\OS; ..\..\Source\APP\SIM900A\Config; ..\..\Source\APP\Protocol; ..\..\Source\APP\Iap; ..\..\Source\BSP; ..\..\Source\BSP\Driver; ..\..\Source\BSP\IAR; ..\..\Source\BSP\Os; ..\..\Source\BSP\Os\uCOS-III; ..\..\Source\BSP\St; ..\..\Source\BSP\St\FWLib\CMSIS\CM3\CoreSupport; ..\..\Source\BSP\St\FWLib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\Source\BSP\St\FWLib\STM32F10x_StdPeriph_Driver\inc; ..\..\Source\Micrium\uC-CPU; ..\..\Source\Micrium\uC-CPU\ARM-Cortex-M3\IAR; ..\..\Source\Micrium\uC-LIB; ..\..\Source\BSP\Os\OSAL; ..\..\Source\OSAL\OS; ..\..\Source\Micrium\uC-MB; ..\..\Source\Micrium\uC-MB\Cfg\Template; ..\..\Source\Micrium\uC-MB\OS\uCOS-III; ..\..\Source\Micrium\uC-MB\Source; ..\..\Source\Micrium\uC-OS-III; ..\..\Source\Micrium\uC-OS-III\Ports\ARM-Cortex-M3\Generic\IAR; ..\..\Source\Micrium\uC-OS-III\Source; ..\..\Source\FatFs; ..\..\Source\FatFs\option; ..\..\Source\APP\Tasks
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NC014-001-000.PRJ_00-Lib.bin
  ILINK.IlinkOutputFile: OS.out
  ILINK.IlinkIcfFile: ..\..\Source\BSP\IAR\STM32_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug-RB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; DEBUG; STM32F103RB; STM32_FLASH_SIZE=128
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\Source\APP; ..\..\Source\APP\User; ..\..\Source\APP\AES; ..\..\Source\APP\Config; ..\..\Source\APP\OS; ..\..\Source\APP\User; ..\..\Source\APP\SIM900A\Source; ..\..\Source\APP\SIM900A\Port; ..\..\Source\APP\SIM900A\OS; ..\..\Source\APP\SIM900A\Config; ..\..\Source\APP\Protocol; ..\..\Source\BSP; ..\..\Source\BSP\Driver; ..\..\Source\BSP\IAR; ..\..\Source\BSP\Os; ..\..\Source\BSP\Os\uCOS-III; ..\..\Source\BSP\St; ..\..\Source\BSP\St\FWLib\CMSIS\CM3\CoreSupport; ..\..\Source\BSP\St\FWLib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\Source\BSP\St\FWLib\STM32F10x_StdPeriph_Driver\inc; ..\..\Source\Micrium\uC-CPU; ..\..\Source\Micrium\uC-CPU\ARM-Cortex-M3\IAR; ..\..\Source\Micrium\uC-LIB; ..\..\Source\BSP\Os\OSAL; ..\..\Source\OSAL\OS; ..\..\Source\Micrium\uC-MB; ..\..\Source\Micrium\uC-MB\Cfg\Template; ..\..\Source\Micrium\uC-MB\OS\uCOS-III; ..\..\Source\Micrium\uC-MB\Source; ..\..\Source\Micrium\uC-OS-III; ..\..\Source\Micrium\uC-OS-III\Ports\ARM-Cortex-M3\Generic\IAR; ..\..\Source\Micrium\uC-OS-III\Source; ..\..\Source\FatFs; ..\..\Source\FatFs\option
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: NC014-001-000.PRJ_00-Lib.sim
configuration Release-RB (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; RELEASE; STM32F103RB; STM32_FLASH_SIZE=128
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: SNL15-013-B-2 Ctrl-Lib-Release-RB.bin
configuration Library-RB (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: SNL15-013-B-2 Ctrl-Lib-Release-RB.bin
configuration Library-RC (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; __RELEASE; __DEBUG; LIBRARY; STM32F103RC; STM32_FLASH_SIZE=256
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\Source\APP; ..\..\Source\APP\User; ..\..\Source\APP\AES; ..\..\Source\APP\Config; ..\..\Source\APP\OS; ..\..\Source\APP\User; ..\..\Source\APP\SIM900A\Source; ..\..\Source\APP\SIM900A\Port; ..\..\Source\APP\SIM900A\OS; ..\..\Source\APP\SIM900A\Config; ..\..\Source\APP\Protocol; ..\..\Source\APP\Iap; ..\..\Source\BSP; ..\..\Source\BSP\Driver; ..\..\Source\BSP\IAR; ..\..\Source\BSP\Os; ..\..\Source\BSP\Os\uCOS-III; ..\..\Source\BSP\St; ..\..\Source\BSP\St\FWLib\CMSIS\CM3\CoreSupport; ..\..\Source\BSP\St\FWLib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\Source\BSP\St\FWLib\STM32F10x_StdPeriph_Driver\inc; ..\..\Source\Micrium\uC-CPU; ..\..\Source\Micrium\uC-CPU\ARM-Cortex-M3\IAR; ..\..\Source\Micrium\uC-LIB; ..\..\Source\BSP\Os\OSAL; ..\..\Source\OSAL\OS; ..\..\Source\Micrium\uC-MB; ..\..\Source\Micrium\uC-MB\Cfg\Template; ..\..\Source\Micrium\uC-MB\OS\uCOS-III; ..\..\Source\Micrium\uC-MB\Source; ..\..\Source\Micrium\uC-OS-III; ..\..\Source\Micrium\uC-OS-III\Ports\ARM-Cortex-M3\Generic\IAR; ..\..\Source\Micrium\uC-OS-III\Source; ..\..\Source\FatFs; ..\..\Source\FatFs\option
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: NC136-02-100-001B.PRJ_00-Lib.sim
configuration Release-RC (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; _STM32F10X_HD; STM32F10X_CL; RELEASE; STM32F103RC; STM32_FLASH_SIZE=256; HSE_VALUE=25000000
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: NC014-100-000.CX_00_Release-RC.bin
configuration Debug-RC-A (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; DEBUG; IMAGE_A; STM32F103RC; STM32_FLASH_SIZE=256
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: NC136B-120-000.CX_00-Lib_Debug-RC_IMAGE_A.bin
  ILINK.IlinkIcfFile: ..\..\Source\BSP\IAR\STM32_Flash_A.icf
configuration Debug-RC-B (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; DEBUG; IMAGE_B; STM32F103RC; STM32_FLASH_SIZE=256
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: NC136-02-100-001B.PRJ_00-Lib-IMAGE_B.bin
  ILINK.IlinkIcfFile: ..\..\Source\BSP\IAR\STM32_Flash_B.icf
configuration Release-RC-A (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; _STM32F10X_HD; STM32F10X_CL; RELEASE; IMAGE_A; STM32F103RC; STM32_FLASH_SIZE=256; HSE_VALUE=25000000
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: NC014-001-000.CX_00_Release-RC_IMAGE_A.bin
  ILINK.IlinkIcfFile: ..\..\Source\BSP\IAR\STM32_Flash_A.icf
configuration Release-RC-Disp (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; RELEASE; DISPLAY; STM32F103RC; STM32_FLASH_SIZE=256
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: NC136B-620-000.CX_00_Release-RC-Disp.bin
configuration Release-RC-A-Disp (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; RELEASE; DISPLAY; IMAGE_A; STM32F103RC; STM32_FLASH_SIZE=256
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: NC136B-620-000.CX_00_Release-RC-Disp_IMAGE_A.bin
  ILINK.IlinkIcfFile: ..\..\Source\BSP\IAR\STM32_Flash_A.icf
  group (top)
    ./: UpdateLog.log
  group APL
    ../../Source/APL/: app_main.c
  group APL/IAP
    ../../Source/APP/Iap/: iap.c
  group APL/task
    ../../Source/APP/Protocol/: app_comm_protocol.c CrcCheck.c
    ../../Source/APP/Tasks/: app_task_comm.c app_task_detect.c task_comm.c
  group APL/USER
    ../../Source/APP/User/: app_var.c sprintf.c
  group BSP/Driver/Board
    ../../Source/BSP/Driver/: bsp_adc7682.c bsp_adc7682.h bsp_dataconversion.c bsp_dataconversion.h bsp_eeprom.c bsp_eeprom.h bsp_filteralgorithm.c bsp_filteralgorithm.h bsp_key.c bsp_key.h bsp_max7219.c bsp_max7219.h bsp_r8025t.c
  group BSP/Driver/Mater
    ../../Source/BSP/Driver/: config.h delay.c delay.h Display.c Display.h DS3231.c DS3231.h FM24CL64.c FM24CL64.h I2C_CLK.c I2C_CLK.h MX25.c mx25.h POWER_MACRO.h RS485.c RS485.h SPI_CS5463_AC.c SPI_CS5463_AC.h SPI_CS5463_DC.c SPI_CS5463_DC.h ST_ICON.c ST_ICON.h SZ_STM32F107VC_LIB.c SZ_STM32F107VC_LIB.h WatchDog.c WatchDog.h xprintf.c xprintf.h
  group BSP/Driver/Mcu
    ../../Source/BSP/Driver/: bsp_adc.c bsp_adc.h bsp_dac.c bsp_flash.c bsp_flash.h bsp_info.c bsp_info.h bsp_pwm.c bsp_pwm.h bsp_rst.c bsp_rst.h bsp_rtc.c bsp_rtc.h bsp_time.c bsp_time.h bsp_usart.c bsp_usart.h bsp_wdt.c bsp_wdt.h
  group BSP/IAR
    ../../Source/BSP/IAR/: cstartup.c STM32_Flash.icf STM32_Flash_A.icf STM32_Flash_B.icf
  group BSP/ST/FWLib/CMSIS
    ../../Source/BSP/ST/FWLib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Source/BSP/ST/FWLib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group BSP/ST/FWLib/inc
    ../../Source/BSP/ST/FWLib/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group BSP/ST/FWLib/src
    ../../Source/BSP/ST/FWLib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP/User
    ../../Source/BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c
  group MB
    ../../Source/Micrium/uC-MB/Source/: MB.C MB.h MB_AES.C MB_DEF.H MB_UTIL.C MBM_CORE.C MBS_CORE.C
    ../../Source/Micrium/uC-MB/Cfg/Template/: mb_app_hooks.c mb_app_hooks.h mb_cfg.h MB_DATA.C
    ../../Source/Micrium/uC-MB/Ports/STM32/STM32F103/IAR/: MB_BSP.C
    ../../Source/Micrium/uC-MB/OS/uCOS-III/: MB_OS.C
